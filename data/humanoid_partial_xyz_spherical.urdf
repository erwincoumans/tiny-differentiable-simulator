Commit message: add missing axis for joints

File: data/humanoid_partial_xyz_spherical.urdf (robot description, URDF)
Before this commit: robot dumpUrdf, 8 links, 7 joints
Joints:
- joint chest: axis (none) -> 1 0 0
- joint right_shoulder: axis (none) -> 1 0 0
